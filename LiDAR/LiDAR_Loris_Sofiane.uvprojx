# Keil uVision project LiDAR_Loris_Sofiane.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LiDAR_Loris_Sofiane
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: baseUART.c Lidar_RTOS.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:Graphic LCD 1.0.0, CMSIS Driver:SPI:SSP 2.5, CMSIS Driver:USART 2.4, Device:GPDMA 1.2, Device:GPIO 1.1, Device:PIN 1.0, Device:Startup 1.0.0
